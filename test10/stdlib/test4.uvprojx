# Keil uVision project test4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test4
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c exti.c key.c led.c delay.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
